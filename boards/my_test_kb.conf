## boards/my_test_kb.conf
```kconfig
CONFIG_ZMK_KEYBOARD=y
CONFIG_ZMK_KSCAN_MATRIX=y
CONFIG_ZMK_BLE=y
CONFIG_ZMK_BLE_KEYBOARD_OUTPUT=y
CONFIG_ZMK_USB=y
```
